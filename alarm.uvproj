# Keil uVision project alarm.uvproj, settings and files
target main (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drivers;.\main;.\pt
  group asemble
    ./: STARTUP.A51
  group main
    ./main/: main.c threads.c
  group drivers
    ./drivers/: configure.c SN74HC595.c configure.h pins.h SN74HC595.h STC15F2K60S2.h peripherals.c
  group pt
    ./pt/: lc.h lc-switch.h pt.h pt-sem.h ex_pt.h
